# IAR project HACS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE; ARM_MATH_CM4; __FPU_PRESENT
  ICCARM.CCIncludePath2: D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\hacs\app\include; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\hacs\platform\include; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\third_party\CMSIS\Device\ST\STM32F4xx\Include; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\third_party\STM32F4xx_HAL_Driver\Inc; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\third_party\FreeRTOS\Source\include; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\hacs\device\inc; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\third_party\MAVLink_output\hacs; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\third_party\MAVLink_output; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\third_party\MadgwickAHRS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\hacs\platform\include
  OBJCOPY.OOCOutputFile: HACS.srec
  ILINK.IlinkOutputFile: HACS.out
  ILINK.IlinkIcfFile: HACS_app_stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../../software/hacs/app/src/: hacs_app.c hacs_console.c hacs_console_commands.c hacs_pilot_cmd.c hacs_pstore_layout.c hacs_sensor_sched.c hacs_sysid.c hacs_system_config.c hacs_telemetry.c
  group boot
    ../../../software/hacs/boot/src/: main.c
  group device
    ../../../software/hacs/device/src/: actuator.c ads1120.c bmp085.c gps_serial.c hmc5883.c mpu6050_serial.c ms4525do.c nrf24l01.c rc_receiver.c
  group platform
    ../../../software/hacs/platform/src/: hacs_crc.c hacs_debug_uart.c hacs_gpio.c hacs_i2c_master.c hacs_platform.c hacs_platform_resources.c hacs_pstore.c hacs_spi_master.c hacs_timer.c hacs_uart.c stm32f4xx_hal_msp.c
    ../../../software/third_party/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f411xe.s
    ../../../software/third_party/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group tps
    ../../../software/third_party/MadgwickAHRS/: MadgwickAHRS.c
  group tps/FreeRTOS
    ../../../software/third_party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group tps/FreeRTOS/portable
    ../../../software/third_party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../software/third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group tps/STM32F4xx_HAL
    ../../../software/third_party/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
