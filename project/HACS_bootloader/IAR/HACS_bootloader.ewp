# IAR project HACS_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F411xE
  ICCARM.CCIncludePath2: D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\third_party\CMSIS\Device\ST\STM32F4xx\Include; D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\software\hacs\platform\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HACS_bootloader.srec
  ILINK.IlinkOutputFile: HACS_bootloader.out
  ILINK.IlinkIcfFile: D:\Anson\Documents\GitHub\Hobby_Airplane_Control_System\project\HACS_bootloader\IAR\HACS_bootloader_stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../software/hacs/boot/src/: bootloader_main.c
    ../../../software/third_party/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f411xe.s
    ../../../software/third_party/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
